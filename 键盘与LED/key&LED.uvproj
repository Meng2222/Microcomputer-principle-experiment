# Keil uVision project key&LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: keyLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c HD7279.c delay.c basicIO.c decode.c p1IO.c dataMemory.c timer.c 89C51_it.c usart.c 8255.c 8254.c 8251A.c CS5550.c pwm.c brushDcMotor.c stepMotor.c speaker.c gpio.c
